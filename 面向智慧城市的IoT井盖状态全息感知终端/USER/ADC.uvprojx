# Keil uVision project ADC.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\HALL;..\HARDWARE\ADC;..\HARDWARE\SYN8086;..\HARDWARE\SPK;..\HARDWARE\BEEP;..\HARDWARE\ICM42688P;..\HARDWARE\TIMER;..\SYSTEM\flag;..\MALLOC;..\HARDWARE\EC01G;..\HARDWARE\STMFLASH;..\HARDWARE\HCSR04;..\HARDWARE\OLED;..\HARDWARE\GPS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/HCSR04/: hcsr04.c
    ../HARDWARE/HALL/: hall.c
    ../HARDWARE/SPK/: nv020c.c
    ../HARDWARE/ICM42688P/: angle.c icm42688.c spi.c
    ../HARDWARE/EC01G/: ec01g.c
    ../HARDWARE/OLED/: oled.c oleddispaly.c
    ../HARDWARE/GPS/: gps.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/flag/: flag.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_spi.c
  group MALLOC
    ../MALLOC/: malloc.c
